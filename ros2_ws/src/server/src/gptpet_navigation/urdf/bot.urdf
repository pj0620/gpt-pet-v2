Commit message: urdf and nav2 config

File: ros2_ws/src/server/src/gptpet_navigation/urdf/bot.urdf (robot description, URDF)
Before this commit: robot mecanum_bot, 6 links, 5 joints
Links:
- link base_laser_link: geometry collision box size=0.12 0.05 0.07; visual box size=0.28 0.07 0.04
